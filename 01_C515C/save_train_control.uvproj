# Keil uVision project save_train_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: C515C-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(10000000) XRAM (0xF800-0xFFFF) MOD517DP
  output: save_train_control
  c flags: Optimize=8 SizeSpeed=1
  c include: ./common;./include;./drivers;./modules
  group common
    ./common/: main.c util.c
  group drivers
    ./drivers/: xpressnet.c rs232.c
  group modules
    ./modules/: betriebsmittelverwaltung.c leitzentrale.c
